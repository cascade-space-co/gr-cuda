options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: default
    output_language: python
    title: Demo
  states: {}

blocks:
- name: buff_size_samples
  id: variable
  parameters:
    comment: |-
      Number of samples per GPU batch. Each block's
      min_output_buffer is set to nbuff x buff_size_samples
      (divided by nfft for vector-length ports). Larger values 
      improve GPU throuput at the cost of memory and latency.
      For finer control, buff_size_samples can also be used as
      output_multiple via set_output_multiple(), but this is 
      not exposed in the flowgraph by default.
    value: 2**20
  states: {}
- name: nbuff
  id: variable
  parameters:
    value: '4'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '65536'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    minoutbuf: nbuff * buff_size_samples
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: cuda_complex_to_mag_squared_cupy_0
  id: cuda_complex_to_mag_squared_cupy
  parameters:
    minoutbuf: nbuff * buff_size_samples // nfft
    vlen: nfft
  states: {}
- name: cuda_fft_0
  id: cuda_fft
  parameters:
    fft_size: nfft
    forward: 'True'
    input_type: complex
    minoutbuf: nbuff * buff_size_samples // nfft
    shift: 'True'
    window: '[]'
  states: {}
- name: cuda_nlog10_cupy_0
  id: cuda_nlog10_cupy
  parameters:
    k: '0'
    minoutbuf: nbuff * buff_size_samples // nfft
    n: '10'
    vlen: nfft
  states: {}
- name: cuda_probe_rate_0
  id: cuda_probe_rate
  parameters:
    alpha: '0.15'
    minoutbuf: nbuff * buff_size_samples
    mintime: '500.0'
    name: ''''''
    type: complex
    vlen: '1'
  states: {}
- name: cuda_stream_to_vector_0
  id: cuda_stream_to_vector
  parameters:
    minoutbuf: nbuff * buff_size_samples // nfft
    num_items: nfft
    type: complex
    vlen: '1'
  states: {}
- name: cuda_throttle_0
  id: cuda_throttle
  parameters:
    minoutbuf: nbuff * buff_size_samples
    sample_rate: 1024e8
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: nfft
    x_axis_label: FFT bin
    x_start: '0'
    x_step: '1.0'
    y_axis_label: Power [dB]
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', cuda_throttle_0, '0']
- [cuda_complex_to_mag_squared_cupy_0, '0', cuda_nlog10_cupy_0, '0']
- [cuda_fft_0, '0', cuda_complex_to_mag_squared_cupy_0, '0']
- [cuda_nlog10_cupy_0, '0', qtgui_vector_sink_f_0, '0']
- [cuda_probe_rate_0, rate, blocks_message_debug_0, print]
- [cuda_stream_to_vector_0, '0', cuda_fft_0, '0']
- [cuda_throttle_0, '0', cuda_probe_rate_0, '0']
- [cuda_throttle_0, '0', cuda_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1089-gad53d9c1
