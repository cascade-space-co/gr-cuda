options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: default
    output_language: python
    title: Demo
  states: {}

blocks:
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: cuda_complex_to_mag_squared_cupy_0
  id: cuda_complex_to_mag_squared_cupy
  parameters:
    vlen: '65536'
  states: {}
- name: cuda_fft_0
  id: cuda_fft
  parameters:
    fft_size: '65536'
    forward: 'True'
    input_type: complex
    shift: 'True'
    window: '[]'
  states: {}
- name: cuda_nlog10_cupy_0
  id: cuda_nlog10_cupy
  parameters:
    k: '0'
    n: '10'
    vlen: '65536'
  states: {}
- name: cuda_probe_rate_0
  id: cuda_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    name: ''''''
    type: complex
    vlen: '1'
  states: {}
- name: cuda_stream_to_vector_0
  id: cuda_stream_to_vector
  parameters:
    num_items: '65536'
    type: complex
    vlen: '1'
  states: {}
- name: cuda_throttle_0
  id: cuda_throttle
  parameters:
    sample_rate: 512e6
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '65536'
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', cuda_throttle_0, '0']
- [cuda_complex_to_mag_squared_cupy_0, '0', cuda_nlog10_cupy_0, '0']
- [cuda_fft_0, '0', cuda_complex_to_mag_squared_cupy_0, '0']
- [cuda_nlog10_cupy_0, '0', qtgui_vector_sink_f_0, '0']
- [cuda_probe_rate_0, rate, blocks_message_debug_0, print]
- [cuda_stream_to_vector_0, '0', cuda_fft_0, '0']
- [cuda_throttle_0, '0', cuda_probe_rate_0, '0']
- [cuda_throttle_0, '0', cuda_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1084-g0711ede3
